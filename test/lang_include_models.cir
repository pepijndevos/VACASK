* ngspice model file
.model resr r
